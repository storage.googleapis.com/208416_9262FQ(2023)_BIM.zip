Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2024-01-28T23:58:39
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Jan 28 23:58:39 2024 * Host: DESKTOP-13TP49N * Database: C:\Users\andre\AppData\Local\Temp\8f60cd24-d351-4d47-92a9-e92f049f2c17\1eba067a-fb18-4def-a1f6-de64687c1412\ifc * Database version: 5507 * Database creation date: Sun Jan 28 23:58:38 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Jan 28 23:58:38 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Jan 28 23:58:38 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Other - Category: Project Information

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCE

# IfcFlowController: 9262FQ Washbasin faucet, 3 V, non-Bluetooth, 9262FQ(2023):9262FQ Washbasin faucet, 3 V, non-Bluetooth:71836
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - FaucetNominalDepth: 168 mm; FaucetNominalHeight: 135 mm; FaucetNominalWidth: 55 mm; HandShowerNominalDepth: 68.5 mm; HandShowerNominalHeight: 316.8 mm; HandShowerNominalWidth: 57 mm; InletConnectionSize: 10 mm
Type - Electrical - Battery: AA 1.5 V Lithium x 2; Bluetooth: No Bluetooth; Electrical Connection: 9 V; Operating Voltage: 39 V; Protection Class: IP 55
Type - General - Author: BIMStone; BIMObjectName: 9262FQ(2023); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 17/01/2024
Type - Green Building Properties - EAN Number: 6414150105203; EMC Directive: Radio Equipment Directive 2014/53/EU , Low Voltage Directive 2014/35/EU , EMC Directive 2014/30/EU , RoHS Directive 2011/65/EU; EN Standard: EN 817, EN 15091, ETSI EN 301 489-1 V1.9.2 , ETSI EN 300 328 v2.2.2 , EN 61000-6-1:2007 , EN 61000-6-3:2007+A1:2011+AC:2012 , EN 60335-1:2012+A11+A13+A1+A14+A2+A15:2021, Part 19.11.4; Sales Package dimensions (LxWxH): 568 x 182 x 78; URL Declaration of Asbestos: http://static.oras.com/doc/asbestos; URL Declaration of Conformity: http://static.oras.com/DoC/9262FQ; URL Declaration Of Performance (DOP): http://static.oras.com/doc/DoP; URL Declaration of SCIP: http://static.oras.com/doc/SCIP; URL EcoLabel Declaration: http://static.oras.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.oras.com/doc/packaging; URL Materials Declaration: http://www.oras.com/fileadmin/resources/189429_9262FQ_materialsdeclaration.pdf; URL REACH: http://static.oras.com/doc/reach; URL WEEE: http://static.oras.com/WEEE/9262FQ
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/9262FQ; Catalog Drawing URL: http://static.oras.com/catdrw/9262FQ; Dimension Drawing URL: http://static.oras.com/dimdrw/9262FQ; FDV Document URL: http://www.oras.com/datasheet/9262FQ/en/fdv; Group: Washbasin faucet; Installation and Maintenance Guide URL: http://static.oras.com/manual/9262FQ; Long Marketing: Touchless faucet with tilt aerator. +/- 10° adjustment option. Easy grip temperature lever for good grip and easy adjustment. SMART intelligent sensor with 3 optical lenses for improved performance SMART Remote bidetta option with automated on and off water function. Brass casted construction and easy installation due to fast and easy 3S installation system; Manufacturer: Oras; Market: International;Finland;Norway;Sweden;Denmark;Poland;Lithuania;Latvia;Ukraine; Mobile Product Information URL: http://mpi.oras.com/9262FQ; Model: 9262FQ Washbasin faucet, 3 V, non-Bluetooth; Name_en: 9262FQ Washbasin faucet, 3 V, non-Bluetooth; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 9262FQ; Product Family: Oras Electra; Product Image URL: http://static.oras.com/image/9262FQ; Product URL: http://static.oras.com/9262FQ; Short Marketing: Electra 92 series give you a clean classic design with beautiful round body flowing into round spout design with a clear design line framing the faucet design. A Classic design for any installation. Key Features Aerator with Tilt function +/- 10° for more flexible installation Newest Sensor technology for better detection and operation comfort Temperature measurement Intuitive bidetta Battery and power cable; Technical DataSheet URL: http://www.oras.com/datasheet/9262FQ/en; Type Name: 9262FQ Washbasin faucet, 3 V, non-Bluetooth; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Advanced Features: 3S-installation system for safe and simple mounting; Aerator: PCA® - constant flow rate regardless of pressure variations; Afterflow Period: 3 s (1-20 s); Automatic Flush Frequency: off (off/1-120 h); Automatic Flush Period: 30 s (1-1800 s); Connection: Flexible inlet pipes; Electronic Parts: ;Light indicated function(s);Low battery indicator; Hand Shower: Bidetta hand shower; Installation Type: Deck mounted; Lever Handle: Temperature control handle; Max Flow Period: 2 min (1 - 1800 s); Mounting Holes: 1 hole; Operating Distance: 20-130 mm (110/130/160 mm); Shower Parts: Hand shower;Shower holder;Shower hose (1750 mm); Spout Type: Fixed spout; Surface treatment: Chrome
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 9262FQ(2023); Features: Touchless;Bidetta;Battery-operated; Finish: Polished; Grade: n/a; ModelNumber: n/a; ModelReference: 9262FQ; Name: 9262FQ Washbasin faucet, 3 V, non-Bluetooth; ReplacementCost: n/a; Shape: Sculptured; Size: Faucet:50x155x175 mm / Hand shower: 55x70x315 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - DistanceX-Axis: 100 mm; DistanceY-Axis: 100 mm; Elevation from Level: 0 mm; FaucetDefaultElevation: 900 mm; HandShowerDefaultElevation: 900 mm; Hand Shower Visibility: yes; Host: Level : Level 1; Level: Level: Level 1; Offset from Host: 0 mm
Dimensions - Area: 0.0841008 m2; Volume: 0.00248884 m3
Identity Data - Mark: 30
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 9262FQ(2023): 9262FQ Washbasin faucet, 3 V, non-Bluetooth; Family and Type: 9262FQ(2023): 9262FQ Washbasin faucet, 3 V, non-Bluetooth; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 9262FQ(2023): 9262FQ Washbasin faucet, 3 V, non-Bluetooth; Type Id: 9262FQ(2023): 9262FQ Washbasin faucet, 3 V, non-Bluetooth; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
